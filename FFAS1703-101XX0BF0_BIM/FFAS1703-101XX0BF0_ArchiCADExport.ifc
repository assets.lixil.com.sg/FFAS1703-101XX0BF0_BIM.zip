Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-01-13T07:14:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 13 07:14:45 2025 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\416dd539-3432-4963-86f7-dc902053cc6c\f59d44ac-9008-4ef8-812e-6f18796d41ca\ifc * Database version: 5507 * Database creation date: Mon Jan 13 07:14:45 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 13 07:14:45 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 13 07:14:45 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: Sanitary_Taps & Mixers_American Standard_Signature 3-Hole Basin Mixer_FFAS1703-101XX0BF0:FFAS1703-101GL0BF0-S-T 3-Hole Basin Mixer With Pop CS, Sanitary_Taps & Mixers_American Standard_Signature 3-Hole Basin Mixer_FFAS1703-101XX0BF0:FFAS1703-101GL0BF0-S-T 3-Hole Basin Mixer With Pop CS:349012
In: Level 1
Type - Material: American Standard - Brass - Cool Sunrise
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: FFAS1703-101GL0BF0-S-T 3-Hole Basin Mixer With Pop CS
Pset_DistributionFlowElementCommon - Reference: FFAS1703-101GL0BF0-S-T 3-Hole Basin Mixer With Pop CS; sets with these values: 2
